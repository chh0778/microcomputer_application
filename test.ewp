# IAR project test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F40_41xxx; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: Libraries\CMSIS\Device\ST\STM32F4xx\Include; Libraries\CMSIS\Include; Libraries; Libraries\STM32F4xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: test.hex
  ILINK.IlinkOutputFile: test.out
  ILINK.IlinkIcfFile: Libraries\stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group EWARM
    Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40_41xxx.s
  group FRAM
    Libraries/: FRAM.c
  group GUI
    Libraries/: GLCD.c GuiObject.c Gulim10_8x16_ASCII.c Gulim20_16x34_ASCII.c Gulim28_24x48_ASCII.c Gulim7_6x10_ASCII.c Gulim8_8x12_ASCII.c ILI9163B.c
  group STM32Fxx_StdPeriph_Driver
    Libraries/: ACC.c ACC.h Que.c Que.h
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_usart.c
  group User
    ./: 2_HW4_2017130036_이찬해.c 2_PR1_2017130036_이찬해.c 2_PR2_2017130036_이찬해.c FRAM_main.c GPIO_Test.c I2C_main.c SPI.c SPI_g.c TIM4_PWM_T4CH3(PB8).c
    Libraries/: Util.c
